options:
  parameters:
    generate_options: qt_gui
    id: top
    output_language: python
    title: iotSDR Single Tone Loopback test
  states: {}

blocks:
- name: period_samples
  id: variable
  parameters:
    value: '0x1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: period_samples
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: iotSDR_iotSDR_Sink_0
  id: iotSDR_iotSDR_Sink
  parameters:
    Tx_Channel: '''SubGhz_CH_2'''
    URL: 10.42.0.128:42400
    bandwidth: '4000000'
    buffer_size: '1024'
    frequency: 902.2e6
    rf_gain: '31'
    sample_rate: '2000000'
  states: {state: disabled}
- name: iotSDR_iotSDR_Source_0
  id: iotSDR_iotSDR_Source
  parameters:
    Rx_Channel: '''SubGhz_CH_1'''
    URL: 10.42.0.128:42400
    agc_mode: 'True'
    bandwidth: '4000000'
    buffer_size: '1024'
    frequency: 902.2e6
    sample_rate: '2000000'
  states: {}
- name: iotSDR_iotSDR_Source_0_0
  id: iotSDR_iotSDR_Source
  parameters:
    Rx_Channel: '''SubGhz_CH_2'''
    URL: 10.42.0.128:42400
    agc_mode: 'True'
    bandwidth: '4000000'
    buffer_size: '1024'
    frequency: 902.2e6
    sample_rate: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
    ymax: '500'
    ymin: '-500'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
    ymax: '500'
    ymin: '-500'
  states: {}

connections:
- [analog_sig_source_x_0, '0', iotSDR_iotSDR_Sink_0, '0']
- [iotSDR_iotSDR_Source_0, '0', qtgui_freq_sink_x_0, '0']
- [iotSDR_iotSDR_Source_0, '0', qtgui_time_sink_x_0, '0']
- [iotSDR_iotSDR_Source_0_0, '0', qtgui_freq_sink_x_0, '1']
- [iotSDR_iotSDR_Source_0_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
