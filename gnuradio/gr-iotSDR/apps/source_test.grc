options:
  parameters:
    generate_options: qt_gui
    id: top
    output_language: python
    title: iotSDR Single Tone Loopback test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: iotSDR_New_subGHz_Source_0
  id: iotSDR_New_subGHz_Source
  parameters:
    URL: '"10.42.0.128:424"'
  states: {}
- name: iotSDR_iotSDR_Source_0
  id: iotSDR_iotSDR_Source
  parameters:
    Rx_Channel: '''SubGhz_CH_1'''
    URL: 10.42.0.128:42400
    agc_mode: 'True'
    bandwidth: '4000000'
    buffer_size: '1024'
    frequency: '902.2'
    sample_rate: '2000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}

connections:
- [iotSDR_iotSDR_Source_0, '0', qtgui_freq_sink_x_0, '0']
- [iotSDR_iotSDR_Source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
